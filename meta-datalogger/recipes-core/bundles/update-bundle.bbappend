RAUC_SLOT_rootfs = "core-image-base"
